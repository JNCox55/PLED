# IAR project Backup of RTOSDemo.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl7mptnnl8n.h
  General.OGChipSelectEditMenu: LM3Sx9xx Luminary LM3Sx9xx
  ICCARM.CCDefines: IAR_ARMCM3_LM; PACK_STRUCT_END=
  ICCARM.CCDiagSuppress: pa082, pe513, pe167, pe550, pe144, pe191, pe177, pa039, pa050
  ICCARM.CCIncludePath2: ; ..\Common\drivers\LuminaryMicro; ..\common\include; ..\..\source\include; webserver; ..\Common\ethernet\uIP\uip-1.0\uip
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  AARM.AUserIncludes: 
  XLINK.XclFile: RTOSDemo.xcl
  group Demo files
    ../Common/Minimal/: BlockQ.c blocktim.c death.c flash.c GenQTest.c integer.c PollQ.c QPeek.c semtest.c
    ./: main.c timertest.c
    ParTest/: ParTest.c
  group Library files
    ../Common/drivers/LuminaryMicro/IAR/: driverlib.r79
    ./: osram128x64x4.c rit128x96x4.c
  group Scheduler files
    ../../Source/portable/MemMang/: heap_2.c
    ../../Source/: list.c queue.c tasks.c
    ../../Source/portable/IAR/ARM_CM3/: port.c portasm.s
  group System files
    ./: startup_ewarm.c
  group uIP files
    webserver/: emac.c http-strings.c httpd-cgi.c httpd-fs.c httpd.c uIP_Task.c
    ../Common/ethernet/uIP/uip-1.0/uip/: psock.c timer.c uip.c uip_arp.c
