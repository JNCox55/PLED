# IAR project cc3000_basic_wifi_application.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: TM4C1294NCPDT TexasInstruments TM4C1294NCPDT
  ICCARM.CCDefines: ewarm; PART_TM4C1294NCPDT; CC3000_USE_BOOSTERPACK2; _POSIX_SOURCE; TARGET_IS_TM4C129_RA0; CC3000_TM4C129_SPI; UART_BUFFERED
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..; ..\..\..\..; ..\..\..\..\cc3000; ..\..\..\..\cc3000\src\host_driver\core_driver; ..\..\..\..\cc3000\drivers\ek-tm4c129; ..\..\..\..\cc3000\src\host_driver; ..\..\..\..\cc3000\src\host_driver\include; ..\..\..\..\cc3000\src\spi; ..\..\..\..\cc3000\src\; ..\..\..\..\cc3000\src\uart
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: ewarm
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: cc3000_basic_wifi_application.bin
  ILINK.IlinkOutputFile: cc3000_basic_wifi_application.out
  ILINK.IlinkIcfFile: cc3000_basic_wifi_application.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Libraries
    ../../../../driverlib/ewarm/Exe/: driverlib.a
  group Source
    ../../../../cc3000/drivers/ek-tm4c129/: board.c
    ./: cc3000_basic_wifi_application.c startup_ewarm.c
    ../../../../cc3000/src/: cc3000lib.c
    ../../../../utils/: cmdline.c uartstdio.c ustdlib.c
