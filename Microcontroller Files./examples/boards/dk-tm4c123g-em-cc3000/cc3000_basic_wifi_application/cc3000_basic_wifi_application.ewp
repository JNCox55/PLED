# IAR project cc3000_basic_wifi_application.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: TM4C123GH6PGE TexasInstruments TM4C123GH6PGE
  ICCARM.CCDefines: ewarm; PART_TM4C123GH6PGE; CC3000_USE_EM; _POSIX_SOURCE; UART_BUFFERED; TARGET_IS_TM4C123_RB1; CC3000_TM4C123_SPI
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..; ..\..\..\..; ..\..\..\..\cc3000; ..\..\..\..\cc3000\src\host_driver\core_driver; ..\..\..\..\cc3000\drivers\dk-tm4c123g; ..\..\..\..\cc3000\src\host_driver; ..\..\..\..\cc3000\src\host_driver\include; ..\..\..\..\cc3000\src\spi; ..\..\..\..\cc3000\src\; ..\..\..\..\cc3000\src\uart
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: ewarm
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: cc3000_basic_wifi_application.bin
  ILINK.IlinkOutputFile: cc3000_basic_wifi_application.out
  ILINK.IlinkIcfFile: cc3000_basic_wifi_application.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Libraries
    ../../../../driverlib/ewarm/Exe/: driverlib.a
    ../../../../grlib/ewarm/Exe/: grlib.a
  group Source
    ../../../../cc3000/drivers/dk-tm4c123g/: board.c
    ./: cc3000_basic_wifi_application.c startup_ewarm.c
    ../../../../cc3000/src/: cc3000lib.c
    ../drivers/: cfal96x64x16.c
    ../../../../utils/: cmdline.c uartstdio.c ustdlib.c
