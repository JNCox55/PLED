# Keil uVision project cc3000_basic_wifi_application.uvproj, settings and files
target cc3000_basic_wifi_application (ARM-ADS)
  device: TM4C123GH6PGE Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: cc3000_basic_wifi_application
  AfterMake: fromelf --bin --output .\rvmdk\cc3000_basic_wifi_application.bin .\rvmdk\cc3000_basic_wifi_application.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: rvmdk PART_TM4C123GH6PGE CC3000_USE_EM _POSIX_SOURCE UART_BUFFERED TARGET_IS_TM4C123_RB1 CC3000_TM4C123_SPI
  c misc: --c99
  c include: ..;..\..\..\..;..\..\..\..\cc3000;..\..\..\..\cc3000\src\host_driver\core_driver;..\..\..\..\cc3000\drivers\dk-tm4c123g;..\..\..\..\cc3000\src\host_driver;..\..\..\..\cc3000\src\host_driver\include;..\..\..\..\cc3000\src\spi;..\..\..\..\cc3000\src\;..\..\..\..\cc3000\src\uart;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: cc3000_basic_wifi_application.sct
  link misc: --entry Reset_Handler
  group Source
    ../../../../cc3000/drivers/dk-tm4c123g/: board.c
    ./: cc3000_basic_wifi_application.c startup_rvmdk.S
    ../../../../cc3000/src/: cc3000lib.c
    ../drivers/: cfal96x64x16.c
    ../../../../utils/: cmdline.c uartstdio.c ustdlib.c
  group Libraries
    ../../../../driverlib/rvmdk/: driverlib.lib
    ../../../../grlib/rvmdk/: grlib.lib
  group Documentation
    ./: readme.txt
