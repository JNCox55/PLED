# Keil uVision project cc3000_ssid_scan.uvproj, settings and files
target cc3000_ssid_scan (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: cc3000_ssid_scan
  AfterMake: fromelf --bin --output .\rvmdk\cc3000_ssid_scan.bin .\rvmdk\cc3000_ssid_scan.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: rvmdk PART_TM4C123GH6PM TARGET_IS_TM4C123_RB1 CC3000_TM4C123_SPI UART_BUFFERED _POSIX_SOURCE
  c misc: --c99
  c include: ..;..\..\..\..;..\..\..\..\cc3000;..\..\..\..\cc3000\src\host_driver\core_driver;..\..\..\..\cc3000\drivers\ek-tm4c123gxl;..\..\..\..\cc3000\src\host_driver;..\..\..\..\cc3000\src\host_driver\include;..\..\..\..\cc3000\src\spi;..\..\..\..\cc3000\src\;..\..\..\..\cc3000\src\uart;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: cc3000_ssid_scan.sct
  link misc: --entry Reset_Handler
  group Source
    ../../../../cc3000/drivers/ek-tm4c123gxl/: board.c
    ./: cc3000_ssid_scan.c startup_rvmdk.S
    ../../../../cc3000/src/: cc3000lib.c
    ../../../../utils/: uartstdio.c
  group Libraries
    ../../../../driverlib/rvmdk/: driverlib.lib
  group Documentation
    ./: readme.txt
